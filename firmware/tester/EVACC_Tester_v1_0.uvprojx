# Keil uVision project EVACC_Tester_v1_0.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EVACC_Tester_v1_0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\ARMCC\include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.0\CMSIS\RTOS2\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.1.0\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c hal.c stm32f10x_it.c lcg-par.c mem.c languages.c Fonts8x5.c utils.c
  group Include
    ./: hal.h stm32f10x_it.h lcg-par.h mem.h messages.h languages.h Fonts8x5.h utils.h
  group Text
    ./: ver.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
