# Keil uVision project EVACC_v3_x.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EVACC_v3_x
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: C:\Keil_v5\ARM\ARMCC\include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.1\CMSIS\RTOS2\RTX\Config;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.1\CMSIS\RTOS2\RTX\Include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.1\CMSIS\RTOS2\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.1.0\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ./: app_main.c dhThread.c CT_Thread.c UIThread.c RFIDThread.c PilotThread.c RFID_Card.c trans.c Fonts8x5.c hal.c languages.c lcg-par.c main.c stm32f10x_it.c i2c_hw.c crc16.c crc32.c tea.c mifare.c ds18b20.c qrcode.c jsmn.c dialog.c
  group include
    ./: hal.h app_main.h Fonts8x5.h languages.h lcg-par.h messages.h stm32f10x_it.h i2c_hw.h UIThread.h CT_Thread.h trans.h PilotThread.h dhThread.h crc16.h crc32.h tea.h mifare.h RFIDThread.h ds18b20.h RFID_Card.h qrcode.h mem.h jsmn.h dialog.h
  group text
    ./: ver.txt JWT.txt
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
